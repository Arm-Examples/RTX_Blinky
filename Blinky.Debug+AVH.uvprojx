# Keil uVision project Blinky.Debug+AVH.uvprojx, settings and files
target Debug+AVH (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Blinky.Debug+AVH.axf
  c flags: Optim=2 v6Lang=3
  c misc: -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality
  c include: ..\Blinky_AVH_RTX
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
  group Documentation
    ./: README.md
  group App
    ./: main.c main.h Blinky.c
  group Board
    ./: retarget_stdio.c
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:UART 1.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
